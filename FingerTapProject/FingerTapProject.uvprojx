# Keil uVision project FingerTapProject.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FingerTapProject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./FTP_Libraries/: FTP_FRAM.c FTP_GFX.c FTP_INPUT.c FTP_NOTES.c FTP_PONG.c FTP_SNAKE.c FTP_ST7735R.c FTP_TETRIS.c FTP_VPAINT.c PLL.c SysTick.c startup.s FTP_MAIN.c
